# Repository eaizy/USB_Isolator

File README.md:

#USB Isolator

<br />This work is licensed under a <a rel="license" href="http://creativecommons.org/licenses/by-nc-sa/4.0/">Creative Commons Attribution-NonCommercial-ShareAlike 4.0 International License</a>.

**⚠️Under Testing**
It seems can work as expectation.

**⚠️PLEASE CAREFULLY USE IT.**

In order to protect my computer, I design this gadget.
为了保证毕业设计时不会因为意外损坏我的电脑，想起来自己有必要开这个坑。

##BOM List
All devices can be found on [element14](http://cn.element14.com/).

|PART NUMBER|Manufacturer Part No|Manufacturer     |Description           |QTY/UNIT|
|:----------|:-------------------|:----------------|:---------------------|-------:|
|1858056    |ADUM4160BRWZ        |ANALOG DEVICES   |Digital Isolator      |1       |
|2533281    |NUP4202W1T2G        |ON SEMICONDUCTOR |ESD Protection Device |2       |
|1615942    |NMG0505SC           |MURATA           |MURATA POWER SOLUTIONS|1       |

To be determined：

| PART | PACKAGE | QTY/UNIT |
|------|---------|----------|
|24Ω   |0402     |4         |
|10kΩ  |0402     |4         |
|0.1µF |0402     |4         |
|10µF  |0805     |2         |
|USB   |mini B(F)|1         |
|USB   |A(F)     |1         |

## EAGLE design USB_Isolator.brd

Parts:
C1, C2: 1µF; C0805
C3, C4, C5, C6: 0.1µF; C0402
J1: USB_A; USB_A_F
J2: USB_MINI
R1, R2, R3, R4: 24Ω; R0402
U1: ADUM4160; SOIC_W-28
U2, U3: NUP4202; SOT-363
U4: NMG0505SC; NMG

Connections:
DD_N: J1.2 (D-), R3.2, U3.6 (IO6)
DD_P: J1.3 (D+), R4.2, U3.4 (IO4)
DGND: C2.2, C5.2, C6.2, J1.4 (GND), J1.5 (SHIELD1), J1.6 (SHIELD2), U1.9 (GND2), U1.15 (GND_2), U3.2 (VN), U4.4 (OUT-)
DVBUS: C2.1, C5.1, J1.1 (VBUS), U1.16 (V_BUS2), U3.5 (VP), U4.6 (OUT+)
DVDD: C6.1, U1.12 (PIN), U1.13 (SPD), U1.14 (VDD2)
unnamed: R2.2, U1.7 (UD+)
unnamed: R1.2, U1.6 (UD-)
unnamed: R4.1, U1.10 (DD+)
unnamed: R3.1, U1.11 (DD-)
UD_N: J2.2 (D-), R1.1, U2.4 (IO4)
UD_P: J2.3 (D+), R2.1, U2.3 (IO3)
UGND: C1.2, C3.1, C4.1, J2.4 (ID), J2.5 (GND), J2.6 (SHIELD1), J2.7 (SHIELD2), J2.8 (SHIELD3), J2.9 (SHIELD4), U1.2 (GND_1), U1.8 (GND1), U2.2 (VN), U4.2 (IN-)
UVBUS: C1.1, C3.2, J2.1 (VBUS), U1.1 (V_BUS1), U2.5 (VP), U4.1 (IN+)
UVDD: C4.2, U1.3 (VDD1), U1.4 (PDEN), U1.5 (SPU)

Notes on the sheet:
Author: Hikoshi(田中くんはいつもけだるげ)

Board: 2 copper layers, 60.2 x 25.1 mm, 16 parts (0 on the bottom side), 14 nets.

## Commit log

2016-12-27 シンボルを作成します
2016-12-27 USB mini パッケージ
2016-12-27 アップデート.gitattributesファイル
2016-12-27 シンボルNUP4202
2016-12-27 部品表をアップロード
2016-12-28 パッケージSC-88/SC70-6/SOT-323
2016-12-28 tKeepout
2017-01-06 すべてのパッケージを作成しました
2017-01-07 A4図面の輪郭と表題欄のスクリプト
2017-01-07 directionラベルを修正
2017-01-09 初めのテスト
2017-01-09 DRC調整
2017-03-10 Start testing
